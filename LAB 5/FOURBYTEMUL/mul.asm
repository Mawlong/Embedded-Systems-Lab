ORG 0000H
MOV A,#100
MOV B,#100
MUL AB
MOV R2,A;LSB1
MOV R0,B;MSB1
MOV A,#100
MOV B,#100
MUL AB
MOV R3,A;LSB2
MOV R1,B;MSB2
MOV A,R2
MOV B,R3
MUL AB
MOV R4,A
MOV R5,B
MOV A,R2
MOV B,R1
MUL AB
MOV R6,B
ADDC A,R5
MOV R5,A
MOV A,R1
MOV B,R4
MUL AB
ADDC A,R5
MOV R5,A
MOV A,B
ADDC A,R6
MOV R6,A
MOV A,R1
MOV B,R2
MUL AB
ADDC A,R6
MOV R6,A
MOV A,B
ADDC A,#00H
MOV R7,A
END